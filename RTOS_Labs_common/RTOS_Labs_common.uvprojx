# Keil uVision project RTOS_Labs_common.uvprojx, settings and files
target RTOS_Labs_common (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_Labs_common
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADC.c can0.c eDisk.c eFile.c esp8266.c heap.c Interpreter.c OS.c ST7735.c UART0int.c
software components: CMSIS:CORE 5.5.0
